<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sbk_m4kn.ewp</path>
    </project>
    <batchBuild />
</workspace>
