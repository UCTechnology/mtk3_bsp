<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adbun_m4gr_serial.ewp</path>
    </project>
    <batchBuild />
</workspace>
