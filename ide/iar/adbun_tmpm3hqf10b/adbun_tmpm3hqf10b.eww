<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\adbun_tmpm3hqf10b.ewp</path>
    </project>
    <batchBuild />
</workspace>
