# IAR project sbk_m4kn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM4KNFYAFG Toshiba TMPM4KNFYAFG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _SBK_M4KN_
  ICCARM.CCDiagSuppress: Pa050,Pe867
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\include\sys; ..\..\..\config; ..\..\..\kernel\knlinc; ..\..\..\device\include; ..\..\..\kernel\sysdepend
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _SBK_M4KN_
  AARM.AUserIncludes: ..\..\..\include; ..\..\..\include\sys; ..\..\..\include\sys\sysdepend\sbk_m4kn; ..\..\..\include\sys\sysdepend\cpu\m4kn; ..\..\..\config; ..\..\..\kernel\knlinc
  OBJCOPY.OOCOutputFile: sbk_m4kn.srec
  ILINK.IlinkOutputFile: sbk_m4kn.out
  ILINK.IlinkIcfFile: config\sbk_m4kn_Flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group app_program
    ../../../app_program/: app_main.c
  group app_serial
    ../../../app_serial/: app_main.c
  group config
    ../../../config/: config.h config_device.h config_func.h config_tm.h
  group device/adc
    ../../../device/adc/: adc.c adc.h adc_cnf.h
  group device/adc/sysdepend/m4kn
    ../../../device/adc/sysdepend/m4kn/: adc_cnf_sysdep.h adc_m4kn.c adc_sysdep.h
  group device/common/drvif
    ../../../device/common/drvif/: msdrvif.c msdrvif.h
  group device/i2c
    ../../../device/i2c/: i2c.c i2c.h i2c_cnf.h
  group device/i2c/sysdepend/m4kn
    ../../../device/i2c/sysdepend/m4kn/: i2c_cnf_sysdep.h i2c_m4kn.c i2c_sysdep.h
  group device/include
    ../../../device/include/: dev_adc.h dev_def.h dev_i2c.h dev_ser.h device.h
  group device/ser
    ../../../device/ser/: ser.c ser.h ser_cnf.h
  group device/ser/sysdepend/m4kn
    ../../../device/ser/sysdepend/m4kn/: ser_base.c ser_cnf_sysdep.h ser_inthdr.c ser_m4kn.c ser_mode_sysdep.h ser_rxbuf.c ser_sysdep.h
  group include/sys
    ../../../include/sys/: inittask.h knldef.h machine.h profile.h queue.h sysdef.h
  group include/sys/sysdepend/cpu/core/armv7m
    ../../../include/sys/sysdepend/cpu/core/armv7m/: machine.h profile.h sysdef.h
  group include/sys/sysdepend/cpu/m4kn
    ../../../include/sys/sysdepend/cpu/m4kn/: machine.h profile.h sysdef.h
  group include/sys/sysdepend/sbk_m4kn
    ../../../include/sys/sysdepend/sbk_m4kn/: machine.h profile.h sysdef.h
  group include/tk
    ../../../include/tk/: dbgspt.h device.h errno.h syscall.h syslib.h tkernel.h typedef.h
  group include/tk/sysdepend/cpu/core/armv7m
    ../../../include/tk/sysdepend/cpu/core/armv7m/: cpudef.h dbgspt.h syslib.h
  group include/tk/sysdepend/cpu/m4kn
    ../../../include/tk/sysdepend/cpu/m4kn/: syslib.h
  group include/tk/sysdepend/sbk_m4kn
    ../../../include/tk/sysdepend/sbk_m4kn/: cpudef.h dbgspt.h syslib.h
  group kernel/inittask
    ../../../kernel/inittask/: inittask.c
  group kernel/knlinc
    ../../../kernel/knlinc/: kernel.h limits.h longlong.h tstdlib.h
  group kernel/sysdepend
    ../../../kernel/sysdepend/: cpu_status.h cpu_task.h sys_msg.h sys_timer.h sysdepend.h
  group kernel/sysdepend/cpu/core/armv7m
    ../../../kernel/sysdepend/cpu/core/armv7m/: cpu_cntl.c cpu_status.h cpu_task.h dispatch.S exc_hdr.c interrupt.c offset.h reset_hdl.c sys_timer.h sysdepend.h
  group kernel/sysdepend/cpu/m4kn
    ../../../kernel/sysdepend/cpu/m4kn/: cpu_status.h cpu_task.h sys_timer.h sysdepend.h vector_tbl.c
  group kernel/sysdepend/sbk_m4kn
    ../../../kernel/sysdepend/sbk_m4kn/: cpu_clock.c cpu_status.h cpu_task.h devinit.c hw_setting.c power_save.c sys_msg.h sys_timer.h sysdepend.h
  group kernel/sysinit
    ../../../kernel/sysinit/: sysinit.c
  group kernel/tkernel
    ../../../kernel/tkernel/: check.h cpuctl.c device.c device.h deviceio.c eventflag.c eventflag.h int.c klock.c klock.h mailbox.c mailbox.h memory.c memory.h mempfix.c mempfix.h mempool.c mempool.h messagebuf.c messagebuf.h misc_calls.c mutex.c mutex.h objname.c power.c ready_queue.h rendezvous.c rendezvous.h semaphore.c semaphore.h sysmgr.h task.c task.h task_manage.c task_sync.c time_calls.c time_calls.h timer.c timer.h tkinit.c wait.c wait.h winfo.h
  group kernel/tstdlib
    ../../../kernel/tstdlib/: bitop.c string.c
  group lib/libtk
    ../../../lib/libtk/: fastlock.c fastmlock.c kmalloc.c
  group lib/libtk/sysdepend/cpu/core/armv7m
    ../../../lib/libtk/sysdepend/cpu/core/armv7m/: int_armv7m.c int_armv7m.h wusec_armv7m.c
  group lib/libtk/sysdepend/cpu/m4kn
    ../../../lib/libtk/sysdepend/cpu/m4kn/: int_m4kn.c ptimer_m4kn.c
  group lib/libtm
    ../../../lib/libtm/: libtm.c libtm.h libtm_printf.c
  group lib/libtm/sysdepend/sbk_m4kn
    ../../../lib/libtm/sysdepend/sbk_m4kn/: tm_com.c
