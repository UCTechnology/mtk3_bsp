# IAR project adbun_tmpm3hqf10b.ewp, settings and files
configuration FROM CMSIS DAP (ARM, debug)
  General.OGChipSelectEditMenu: TMPM3HQF10BFG Toshiba TMPM3HQF10BFG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _ADBUN_TMPM3HQF10B_; IAR; ADBUN_TMPM3HQF10B; SERIAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050,Pe867
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\include; ..\..\..\include\sys; ..\..\..\kernel\knlinc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _ADBUN_TMPM3HQF10B_
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\include; ..\..\..\include\sys; ..\..\..\include\sys\sysdepend\adbun_tmpm3hqf10b; ..\..\..\include\sys\sysdepend\cpu\tmpm3hqf10b
  OBJCOPY.OOCOutputFile: adbun_tmpm3hqf10b.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\adbun_tmpm3hqf10b_Flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group app_sample
    ../../../app_program/: app_main.c
  group app_serial
    ../../../app_serial/: app_main.c
  group config
    ../../../config/: config.h config_device.h config_func.h config_tm.h
  group device/common/drvif
    ../../../device/common/drvif/: msdrvif.c msdrvif.h
  group device/include
    ../../../device/include/: dev_def.h dev_ser.h device.h
  group device/ser
    ../../../device/ser/: ser.c ser.h ser_cnf.h
  group device/ser/sysdepend/tmpm3hqf10b
    ../../../device/ser/sysdepend/tmpm3hqf10b/: ser_cnf_sysdep.h ser_mode_sysdep.h ser_sysdep.h ser_tmpm3hqf10b.c
  group include/sys
    ../../../include/sys/: inittask.h knldef.h machine.h profile.h queue.h sysdef.h
  group include/sys/sysdepend/adbun_tmpm3hqf10b
    ../../../include/sys/sysdepend/adbun_tmpm3hqf10b/: machine.h profile.h sysdef.h
  group include/sys/sysdepend/cpu/core/armv7m
    ../../../include/sys/sysdepend/cpu/core/armv7m/: machine.h profile.h sysdef.h
  group include/sys/sysdepend/cpu/tmpm3hqf10b
    ../../../include/sys/sysdepend/cpu/tmpm3hqf10b/: machine.h profile.h sysdef.h
  group include/tk
    ../../../include/tk/: dbgspt.h device.h errno.h syscall.h syslib.h tkernel.h typedef.h
  group include/tk/sysdepend/adbun_tmpm3hqf10b
    ../../../include/tk/sysdepend/adbun_tmpm3hqf10b/: cpudef.h dbgspt.h syslib.h
  group include/tk/sysdepend/cpu/core/armv7m
    ../../../include/tk/sysdepend/cpu/core/armv7m/: cpudef.h dbgspt.h syslib.h
  group include/tk/sysdepend/cpu/tmpm3hqf10b
    ../../../include/tk/sysdepend/cpu/tmpm3hqf10b/: syslib.h
  group include/tm
    ../../../include/tm/: tmonitor.h
  group kernel/inittask
    ../../../kernel/inittask/: inittask.c
  group kernel/knlinc
    ../../../kernel/knlinc/: kernel.h limits.h longlong.h tstdlib.h
  group kernel/sysdepend
    ../../../kernel/sysdepend/: cpu_status.h cpu_task.h sys_msg.h sys_timer.h sysdepend.h
  group kernel/sysdepend/adbun_tmpm3hqf10b
    ../../../kernel/sysdepend/adbun_tmpm3hqf10b/: cpu_clock.c cpu_status.h cpu_task.h devinit.c hw_setting.c power_save.c sys_msg.h sys_timer.h sysdepend.h
  group kernel/sysdepend/cpu/core/armv7m
    ../../../kernel/sysdepend/cpu/core/armv7m/: cpu_cntl.c cpu_status.h cpu_task.h dispatch.S exc_hdr.c interrupt.c offset.h reset_hdl.c sys_timer.h sysdepend.h
  group kernel/sysdepend/cpu/tmpm3hqf10b
    ../../../kernel/sysdepend/cpu/tmpm3hqf10b/: cpu_status.h cpu_task.h sys_timer.h sysdepend.h vector_tbl.c
  group kernel/sysinit
    ../../../kernel/sysinit/: sysinit.c
  group kernel/tkernel
    ../../../kernel/tkernel/: check.h cpuctl.c device.c device.h deviceio.c eventflag.c eventflag.h int.c klock.c klock.h mailbox.c mailbox.h memory.c memory.h mempfix.c mempfix.h mempool.c mempool.h messagebuf.c messagebuf.h misc_calls.c mutex.c mutex.h objname.c power.c ready_queue.h rendezvous.c rendezvous.h semaphore.c semaphore.h sysmgr.h task.c task.h task_manage.c task_sync.c time_calls.c time_calls.h timer.c timer.h tkinit.c wait.c wait.h winfo.h
  group kernel/tsdlib
    ../../../kernel/tstdlib/: bitop.c string.c
  group kernel/usermain
    ../../../kernel/usermain/: usermain.c
  group lib/libtk
    ../../../lib/libtk/: fastlock.c fastmlock.c kmalloc.c
  group lib/libtk/sysdepend/cpu/core/armv7m
    ../../../lib/libtk/sysdepend/cpu/core/armv7m/: int_armv7m.c int_armv7m.h wusec_armv7m.c
  group lib/libtk/sysdepend/cpu/tmpm3hqf10b
    ../../../lib/libtk/sysdepend/cpu/tmpm3hqf10b/: int_tmpm3hqf10b.c ptimer_tmpm3hqf10b.c
  group lib/libtm
    ../../../lib/libtm/: libtm.c libtm.h libtm_printf.c
  group lib/libtm/sysdepend/adbun_tmpm3hqf10b
    ../../../lib/libtm/sysdepend/adbun_tmpm3hqf10b/: tm_com.c
