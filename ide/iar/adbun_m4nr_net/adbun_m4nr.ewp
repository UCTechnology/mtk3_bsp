# IAR project adbun_m4nr.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM4NRF20FG Toshiba TMPM4NRF20FG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _ADBUN_M4NR_; _SIZE_T
  ICCARM.CCDiagSuppress: Pa050,Pe867
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\include\sys; ..\..\..\config; ..\..\..\kernel\knlinc; ..\..\..\device\include; ..\..\..\lib\liblwip\include; ..\..\..\lib\liblwip\lwip\src\include; ..\..\..\app_net
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _ADBUN_M4NR_
  AARM.AUserIncludes: ..\..\..\include; ..\..\..\include\sys; ..\..\..\include\sys\sysdepend\adbun_m4nr; ..\..\..\include\sys\sysdepend\cpu\m4nr; ..\..\..\config; ..\..\..\kernel\knlinc
  OBJCOPY.OOCOutputFile: adbun_m4nr.srec
  ILINK.IlinkOutputFile: adbun_m4nr.out
  ILINK.IlinkIcfFile: config\adbun_m4nr_Flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group app_net
    ../../../app_net/: app_main_dhcp.c app_main_httpd.c lwipopts.h
  group config
    ../../../config/: config.h config_device.h config_func.h config_tm.h
  group device/adc
    ../../../device/adc/: adc.c adc.h adc_cnf.h
  group device/adc/sysdepend/m4nr
    ../../../device/adc/sysdepend/m4nr/: adc_cnf_sysdep.h adc_m4nr.c adc_sysdep.h
  group device/common/drvif
    ../../../device/common/drvif/: mgdrvif.c mgdrvif.h msdrvif.c msdrvif.h
  group device/i2c
    ../../../device/i2c/: i2c.c i2c.h i2c_cnf.h
  group device/i2c/sysdepend/m4nr
    ../../../device/i2c/sysdepend/m4nr/: i2c_cnf_sysdep.h i2c_m4nr.c i2c_sysdep.h
  group device/include
    ../../../device/include/: dev_adc.h dev_def.h dev_i2c.h dev_net.h dev_ser.h device.h
  group device/net
    ../../../device/net/: net.c net.h net_cnf.h net_stat.c net_stat.h net_util.c net_util.h
  group device/net/sysdepend/m4nr
    ../../../device/net/sysdepend/m4nr/: endian.h net_ether.c net_ether.h netdrv_macctrl.c netdrv_macctrl.h
  group device/ser
    ../../../device/ser/: ser.c ser.h ser_cnf.h
  group device/ser/sysdepend/m4nr
    ../../../device/ser/sysdepend/m4nr/: ser_base.c ser_cnf_sysdep.h ser_inthdr.c ser_m4nr.c ser_mode_sysdep.h ser_rxbuf.c ser_sysdep.h
  group include/sys
    ../../../include/sys/: inittask.h knldef.h machine.h profile.h queue.h sysdef.h
  group include/sys/sysdepend/adbun_m4nr
    ../../../include/sys/sysdepend/adbun_m4nr/: machine.h profile.h sysdef.h
  group include/sys/sysdepend/cpu/core/armv7m
    ../../../include/sys/sysdepend/cpu/core/armv7m/: machine.h profile.h sysdef.h
  group include/sys/sysdepend/cpu/m4nr
    ../../../include/sys/sysdepend/cpu/m4nr/: machine.h profile.h sysdef.h
  group include/tk
    ../../../include/tk/: dbgspt.h device.h errno.h syscall.h syslib.h tkernel.h typedef.h
  group include/tk/sysdepend/adbun_m4nr
    ../../../include/tk/sysdepend/adbun_m4nr/: cpudef.h dbgspt.h syslib.h
  group include/tk/sysdepend/cpu/core/armv7m
    ../../../include/tk/sysdepend/cpu/core/armv7m/: cpudef.h dbgspt.h syslib.h
  group include/tk/sysdepend/cpu/m4nr
    ../../../include/tk/sysdepend/cpu/m4nr/: syslib.h
  group kernel/inittask
    ../../../kernel/inittask/: inittask.c
  group kernel/knlinc
    ../../../kernel/knlinc/: kernel.h limits.h longlong.h tstdlib.h
  group kernel/sysdepend
    ../../../kernel/sysdepend/: cpu_status.h cpu_task.h sys_msg.h sys_timer.h sysdepend.h
  group kernel/sysdepend/adbun_m4nr
    ../../../kernel/sysdepend/adbun_m4nr/: cpu_clock.c cpu_status.h cpu_task.h devinit.c hw_setting.c power_save.c sys_msg.h sys_timer.h sysdepend.h
  group kernel/sysdepend/cpu/core/armv7m
    ../../../kernel/sysdepend/cpu/core/armv7m/: cpu_cntl.c cpu_status.h cpu_task.h dispatch.S exc_hdr.c interrupt.c offset.h reset_hdl.c sys_timer.h sysdepend.h
  group kernel/sysdepend/cpu/m4nr
    ../../../kernel/sysdepend/cpu/m4nr/: cpu_status.h cpu_task.h sys_timer.h sysdepend.h vector_tbl.c
  group kernel/sysinit
    ../../../kernel/sysinit/: sysinit.c
  group kernel/tkernel
    ../../../kernel/tkernel/: check.h cpuctl.c device.c device.h deviceio.c eventflag.c eventflag.h int.c klock.c klock.h mailbox.c mailbox.h memory.c memory.h mempfix.c mempfix.h mempool.c mempool.h messagebuf.c messagebuf.h misc_calls.c mutex.c mutex.h objname.c power.c ready_queue.h rendezvous.c rendezvous.h semaphore.c semaphore.h sysmgr.h task.c task.h task_manage.c task_sync.c time_calls.c time_calls.h timer.c timer.h tkinit.c wait.c wait.h winfo.h
  group kernel/tstdlib
    ../../../kernel/tstdlib/: bitop.c string.c
  group lib/liblwip
    ../../../lib/liblwip/: sys_arch.c sys_rand.c sys_sio.c tknetif.c
  group lib/liblwip/include/arch
    ../../../lib/liblwip/include/arch/: cc.h lib.h perf.h sys_arch.h
  group lib/liblwip/lwip/src/api
    ../../../lib/liblwip/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lib/liblwip/lwip/src/apps/http
    ../../../lib/liblwip/lwip/src/apps/http/: fs.c httpd.c
  group lib/liblwip/lwip/src/core
    ../../../lib/liblwip/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lib/liblwip/lwip/src/core/ipv4
    ../../../lib/liblwip/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lib/liblwip/lwip/src/include/lwip
    ../../../lib/liblwip/lwip/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lib/liblwip/lwip/src/netif
    ../../../lib/liblwip/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lib/liblwip/lwip/src/netif/ppp
    ../../../lib/liblwip/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lib/liblwip/lwip/src/netif/ppp/polarssl
    ../../../lib/liblwip/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group lib/libtk
    ../../../lib/libtk/: fastlock.c fastmlock.c kmalloc.c
  group lib/libtk/sysdepend/cpu/core/armv7m
    ../../../lib/libtk/sysdepend/cpu/core/armv7m/: int_armv7m.c int_armv7m.h wusec_armv7m.c
  group lib/libtk/sysdepend/cpu/m4nr
    ../../../lib/libtk/sysdepend/cpu/m4nr/: int_m4nr.c ptimer_m4nr.c
  group lib/libtm
    ../../../lib/libtm/: libtm.c libtm.h libtm_printf.c
  group lib/libtm/sysdepend/adbun_m4nr
    ../../../lib/libtm/sysdepend/adbun_m4nr/: tm_com.c
